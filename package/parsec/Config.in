## package/parsec/Config.in
```kconfig
config BR2_PACKAGE_PARSEC
	bool "parsec"
	default y
	help
		Parsec-3.0 Benchmarks.
```
